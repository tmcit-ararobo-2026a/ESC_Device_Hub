# Repository tmcit-ararobo-2026a/ESC_Device_Hub

File README.md:

# <リポジトリ名>

<!-- 一行でプロジェクトを説明する -->
<プロジェクトの概要を1〜2文で記述>

## 目次

1. [概要](#1-概要)
2. [ドキュメント](#2-ドキュメント)
3. [コントリビューション](#3-コントリビューション)
4. [ビルド・使い方](#4-ビルド使い方)
5. [システム構成](#5-システム構成)
6. [ライセンス](#6-ライセンス)

## 1. 概要

<!-- プロジェクトの目的・背景・解決する課題を記述 -->

## 2. ドキュメント

| ドキュメント | 説明 |
| :-: | :-: |
| [CONTRIBUTING.md](./CONTRIBUTING.md) | 開発フロー・コミット規約・コーディング規約 |
| [docs/requirements-definition.md](./docs/requirements-definition.md) | 要件定義書 |
| [docs/coding-rules.md](./docs/coding-rules.md) | コーディング規約の詳細 |
| [docs/uml/](./docs/uml/) | UML図 |

## 3. コントリビューション

[CONTRIBUTING.md](./CONTRIBUTING.md) を参照してください。

## 4. ビルド・使い方

<!-- ビルドのやり方 -->
<!-- 使い方 -->

## 5. システム構成

<!-- ROS2ノード構成・STM32との通信方式・ハードウェア構成 等 -->
<!-- 依存クラスが3つ以上ある場合は docs/uml/ にUML図を作成し、ここにリンクする -->

## 6. ライセンス

本リポジトリは [MITライセンス](./LICENSE) のもとで公開されています。

## KiCad design PCB/ESC_Device_Hub_v1/ESC_Device_Hub_v1.kicad_pcb

Parts:
C1, C2, C7: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C12, C13, C14, C15, C16, C17, C18, C19, C21, C23, C25, C27: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C6: 0.01uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C10, C26, C28: 2.2uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C11: 0.33uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C20: 4.7uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C22, C24, C32: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C29: 6.8uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C30, C31, C34, C35: 3pF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D2, D7, D8, D9, D12: W; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3, D4: R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: G; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10, D11, D16, D17, D22, D23, D25, D26: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: 600Ω/500mA; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2, J3, J4, J5, J6: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J7, J8, J9, J10: Conn_01x06; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J11, J12, J13, J14, J15, J16, J17, J18, J22: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J19: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
J20, J21: Conn_01x01; 5x5
JP1, JP2: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R4: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R10, R11, R12, R13, R14, R15, R16, R17, R19, R20, R21, R22, R23, R25, R46, R47, R54, R55, R62, R63, R67, R68: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R24: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R43, R44, R51, R52, R59, R60, R65, R66: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R77, R78: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW1, SW2: SW_Push; switch_TVAF06-A020B-R
SW4: SW_DIP_x02; KHS22E
U1: ISO1042BQDWVQ1; SOIC-8_7.5x5.85mm_P1.27mm
U2: MCP2562FD-H/MF; DFN-8-1EP_3x3mm_P0.65mm_EP1.6x2.56mm
U3: IS25LP064D-JLLE; WSON-8-1EP_8x6mm_P1.27mm_EP3.4x4.3mm
U4: STM32H563RGVx; QFN-68-1EP_8x8mm_P0.4mm_EP6.4x6.4mm
U6: TLP293; SOIC-4_4.55x2.6mm_P1.27mm
U7: NJM2884U1-33; SOT-89-5
U8: RFM-0505S
U10, U11: LM66100DCK; SOT-363_SC-70-6
U18: USB_Type-C; USB_C_Receptacle_Nelton_5077CR-16-SMC2-BK-TR
Y1: FC2012SN 32.768K-70NNA0KC0
Y2: XRCGB25M000FFS1AR0

Connections:
+3.3V: C2.1, C3.1, C5.1, C10.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C32.1, J7.5, J8.5, J9.5, J10.5, J19.5, R17.1, R24.1, R43.2, R44.2, R46.2, R47.2, R51.2, R52.2, R54.2, R55.2, R59.2, R60.2, R62.2, R63.2, R65.2, R66.2, R67.2, R68.2, SW2.1, SW4.1, SW4.2, U1.1 (VCC1), U2.5 (Vio), U3.8 (Vcc), U4.1 (VBAT), U4.13 (VDDA), U4.19 (VDD), U4.33 (VDD), U4.51 (VDD), U4.68 (VDD), U6.4, U7.4 (Vout)
+5V: C4.1, C11.1, C13.1, C15.1, C29.1, R16.1, R18.1, U2.3 (VDD), U7.5 (Vin), U8.2 (+Vin), U10.6 (VOUT), U11.6 (VOUT)
+5VA: C14.1, J1.3, J2.3, R15.1, U10.1 (VIN)
+5VP: C1.1, R8.1, U1.8 (VCC2), U8.4 (+Vout)
BOOT0: R3.1, SW2.2, U4.62 (BOOT0)
CAN_H: J1.4, J2.4, R1.2, U2.7 (CANH)
CAN_L: J1.2, J2.2, JP2.1 (A), U2.6 (CANL)
ENC1_A: J7.6, U4.41 (PC7)
ENC1_B: J7.4, U4.40 (PC6)
ENC2_A: J8.6, U4.45 (PA9)
ENC2_B: J8.4, U4.44 (PA8)
ENC3_A: J9.6, U4.59 (PB5)
ENC3_B: J9.4, U4.58 (PB4(NJTRST))
ENC4_A: J10.6, U4.61 (PB7)
ENC4_B: J10.4, U4.60 (PB6)
ESC_FDCAN_RXD: U1.3 (RXD), U4.34 (PB12)
ESC_FDCAN_TXD: U1.2 (TXD), U4.35 (PB13)
FDCAN_RXD: U2.4 (RXD), U4.63 (PB8)
FDCAN_TXD: U2.1 (TXD), U4.64 (PB9)
FLASH_IO0: U3.5 (SI(IO0)), U4.27 (PB1)
FLASH_IO1: U3.2 (SO(IO1)), U4.26 (PB0)
FLASH_IO2: U3.3 (WP(IO2)), U4.23 (PA7)
FLASH_IO3: U3.7 (HOLD/RESET(IO3)), U4.22 (PA6)
FLASH_SCK: U3.6 (SCK), U4.28 (PB2)
FLASH_SS: R24.2, U3.1 (CE#), U4.29 (PB10)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C34.2, C35.2, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D12.1 (K), J1.1, J2.1, J7.1, J7.2, J7.3, J8.1, J8.2, J8.3, J9.1, J9.2, J9.3, J10.1, J10.2, J10.3, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, J18.1, J19.4, R3.2, R19.2, R20.2, R21.2, R22.2, R25.2, R77.2, R78.2, SW1.1, U1.4 (GND1), U2.2 (VSS), U2.8 (STBY), U2.9 (EP), U3.4 (GND), U3.9 (GND), U4.12 (VSSA), U4.18 (VSS), U4.32 (VSS)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
GNDD: C1.2, D1.1 (K), D2.1 (K), J3.1, J3.3, J4.1, J4.3, J5.1, J5.3, J6.1, J6.3, J21.1 (Pin_1_1), U1.5 (GND2), U6.2, U8.3 (-Vout)
HSE_IN: C34.1, U4.5 (PH0), Y2.1
HSE_OUT: C35.1, U4.6 (PH1), Y2.3 (2)
ID_2: R25.1, SW4.4, U4.54 (PC10)
ID_4: R20.1, SW4.3, U4.53 (PA15(JTDI))
Isolation_FDCAN_H: J3.4, J4.4, J5.4, J6.4, JP1.1 (A), R2.1, U1.7 (CANH)
Isolation_FDCAN_L: J3.2, J4.2, J5.2, J6.2, R2.2, R4.2, U1.6 (CANL)
LED_1: R10.1, U4.15 (PA1)
LED_2: R11.1, U4.14 (PA0)
LED_3: R12.1, U4.11 (PC3)
LED_4: R13.1, U4.10 (PC2)
LIMS1_1: D10.1 (K), J11.2, R43.1, U4.36 (PB14)
LIMS1_2: D16.1 (K), J12.2, R51.1, U4.37 (PB15)
LIMS2_1: D22.1 (K), J13.2, R59.1, U4.38 (PD11)
LIMS2_2: D25.1 (K), J14.2, R65.1, U4.39 (PD12)
LIMS3_1: D11.1 (K), J15.2, R44.1, U4.42 (PC8)
LIMS3_2: D17.1 (K), J16.2, R52.1, U4.43 (PC9)
LIMS4_1: D23.1 (K), J17.2, R60.1, U4.20 (PA4)
LIMS4_2: D26.1 (K), J18.2, R66.1, U4.46 (PA10)
NRST: C7.1, J19.1, SW1.2, U4.7 (NRST)
unnamed: C25.1, C26.1, U4.31 (VCAP)
unnamed: C27.1, C28.1, U4.66 (VCAP)
unnamed: D1.2 (A), R14.2
unnamed: D2.2 (A), R8.2
unnamed: D3.2 (A), R10.2
unnamed: D4.2 (A), R11.2
unnamed: D5.2 (A), R12.2
unnamed: D6.2 (A), R13.2
unnamed: D7.2 (A), R15.2
unnamed: D8.2 (A), R16.2
unnamed: D9.2 (A), R17.2
unnamed: D10.2 (A), R46.1
unnamed: D11.2 (A), R47.1
unnamed: D12.2 (A), R23.2
unnamed: D16.2 (A), R54.1
unnamed: D17.2 (A), R55.1
unnamed: D22.2 (A), R62.1
unnamed: D23.2 (A), R63.1
unnamed: D25.2 (A), R67.1
unnamed: D26.2 (A), R68.1
unnamed: JP1.2 (B), R4.1
unnamed: JP2.2 (B), R1.1
unnamed: R9.2, U6.1
unnamed: R18.2, U7.1 (CONT)
unnamed: C12.1, FB1.2, U11.1 (VIN)
unnamed: R78.1, U18.A5 (CC1)
unnamed: R77.1, U18.B5 (CC2)
POWER_MONITOR: R19.1, U4.57 (PB3(JTDO), U6.3
SWCLK: J19.2, U4.52 (PA14(JTCK)
SWDIO: J19.3, U4.49 (PA13(JTMS)
Synchronization_clock: J22.1, R22.1, U4.17 (PA3)
Synchronization_flag: J22.2, R21.1, U4.16 (PA2)
USB_DFU_DM: U4.47 (PA11), U18.A7 (D-), U18.B7 (D-)
USB_DFU_DP: U4.48 (PA12), U18.A6 (D+), U18.B6 (D+)
VBUS: C6.1, FB1.1, R23.1, U18.A4 (VBUS), U18.B4 (VBUS)
VDD: J20.1 (Pin_1_1), R9.1, R14.1
XTAL_IN: C31.1, U4.3 (PC14), Y1.1 (X'tal)
XTAL_OUT: C30.1, U4.4 (PC15), Y1.2 (X'tal)

Notes on the sheet:
ESC-Control-Hub_v0
NOR FLASH x1
STM-DFU
LSE
エンコーダー x4
HSE
制御側電源
FDCAN x2
絶縁FDCAN x4
駆動側電源
リミットスイッチ x8
外部クロック

Board: 4 copper layers, 50.0 x 90.0 mm, 134 parts (12 on the bottom side), 84 nets.

Other parts of the board:
H2, H2#2, H2#3, H2#4: MountingHole; MountingHole_3.2mm_M3

File PCB/ESC_Device_Hub_v1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C7",0603,3,0.1uF,
"C10, C26, C28",0402,3,2.2uF,
C11,0402,1,0.33uF,
"C12, C13, C14, C15, C16, C17, C18, C19, C21, C23, C25, C27, C3, C4, C5",0402,15,0.1uF,
C20,0402,1,4.7uF,
"C22, C24, C32",0402,3,1uF,
C29,0603,1,6.8uF,
"C30, C31, C34, C35",0402,4,3pF,
C6,0402,1,0.01uF,
"D1, D12, D2, D7, D8, D9",0603,6,W,
"D10, D11, D16, D17, D22, D23, D25, D26",0603,8,LED,
"D3, D4",0603,2,R,
D5,0603,1,B,
D6,0603,1,G,
FB1,0603,1,600Ω/500mA,
"H2_4, H2_3, H2_2, H2",MountingHole_3.2mm_M3,4,MountingHole,
"J1, J2, J3, J4, J5, J6",JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,6,Conn_01x04,
"J10, J7, J8, J9",JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical,4,Conn_01x06,
"J11, J12, J13, J14, J15, J16, J17, J18, J22",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,9,Conn_01x02,
J19,PinSocket_1x05_P2.54mm_Vertical,1,Conn_01x05,
"J20, J21",5x5,2,Conn_01x01,
"JP1, JP2",PinHeader_1x02_P2.54mm_Vertical,2,Jumper_2_Bridged,
"R1, R2, R4",0603,3,120,
"R10, R11, R12, R13, R14, R15, R16, R17, R19, R20, R21, R22, R23, R25, R46, R47, R54, R55, R62, R63, R67, R68, R8",0603,23,1k,
R18,0402,1,1k,
R24,0402,1,10k,
"R3, R9",0603,2,10k,
"R43, R44, R51, R52, R59, R60, R65, R66",0603,8,22k,
"R77, R78",0402,2,4.7k,
"SW1, SW2",switch_TVAF06-A020B-R,2,SW_Push,
SW4,KHS22E,1,SW_DIP_x02,
U1,SOIC-8_7.5x5.85mm_P1.27mm,1,ISO1042BQDWVQ1,
"U10, U11",SOT-363_SC-70-6,2,LM66100DCK,
U18,USB_C_Receptacle_Nelton_5077CR-16-SMC2-BK-TR,1,USB_Type-C,
U2,DFN-8-1EP_3x3mm_P0.65mm_EP1.6x2.56mm,1,MCP2562FD-H/MF,
U3,WSON-8-1EP_8x6mm_P1.27mm_EP3.4x4.3mm,1,IS25LP064D-JLLE,
U4,QFN-68-1EP_8x8mm_P0.4mm_EP6.4x6.4mm,1,STM32H563RGVx,
U6,SOIC-4_4.55x2.6mm_P1.27mm,1,TLP293,
U7,SOT-89-5,1,NJM2884U1-33,
U8,RFM-0505S,1,RFM-0505S,
Y1,FC2012SN 32.768K-70NNA0KC0,1,FC2012SN 32.768K-70NNA0KC0,
Y2,XRCGB25M000FFS1AR0,1,XRCGB25M000FFS1AR0,

## Code that names these connections

File esc-control-hub.ioc (part):

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Mcu.Name=STM32H563RGVx
Mcu.Package=VFQFPN68
Mcu.UserName=STM32H563RGVx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=LED_2
PA0.Signal=GPIO_Output
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=LED_1
PA1.Signal=GPIO_Output
PA10.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PA10.GPIO_Label=LIM4_2
PA10.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PA10.Signal=GPXTI10
PA13(JTMS/SWDIO).Mode=Serial_Wire
PA13(JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14(JTCK/SWCLK).Mode=Serial_Wire
PA14(JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA15(JTDI).GPIOParameters=GPIO_Label
PA15(JTDI).GPIO_Label=ID_4_SW
PA15(JTDI).Signal=GPIO_Input
PA4.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PA4.GPIO_Label=LIM4_1
PA4.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PA4.Signal=GPXTI4
PA8.GPIOParameters=GPIO_Speed
PA8.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB12.Mode=FDCAN_Activate
PB12.Signal=FDCAN2_RX
PB13.Mode=FDCAN_Activate
PB13.Signal=FDCAN2_TX
PB14.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PB14.GPIO_Label=LIM1_1
PB14.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PB14.Signal=GPXTI14
PB15.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PB15.GPIO_Label=LIM1_2
PB15.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PB15.Signal=GPXTI15
PB3(JTDO/TRACESWO).GPIOParameters=GPIO_Label
PB3(JTDO/TRACESWO).GPIO_Label=POWER_MONITOR
PB3(JTDO/TRACESWO).Signal=GPIO_Input
PB4(NJTRST).Signal=S_TIM3_CH1
PB5.Signal=S_TIM3_CH2
PB6.Signal=S_TIM4_CH1
PB7.Signal=S_TIM4_CH2
PB8.Mode=FDCAN_Activate
PB8.Signal=FDCAN1_RX
PB9.Mode=FDCAN_Activate
PB9.Signal=FDCAN1_TX
PC10.GPIOParameters=GPIO_Label
PC10.GPIO_Label=ID_2_SW
PC10.Signal=GPIO_Input
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=LED_4
PC2.Signal=GPIO_Output
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=LED_3
PC3.Signal=GPIO_Output
PC6.Signal=S_TIM8_CH1
PC7.Signal=S_TIM8_CH2
PC8.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PC8.GPIO_Label=LIM3_1
PC8.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PC8.Signal=GPXTI8
PC9.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PC9.GPIO_Label=LIM3_2
PC9.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PC9.Signal=GPXTI9
PD11.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PD11.GPIO_Label=LIM2_1
PD11.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PD11.Signal=GPXTI11
PD12.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PD12.GPIO_Label=LIM2_2
PD12.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PD12.Signal=GPXTI12
RCC.HSE_VALUE=24000000
RCC.SYSCLKFreq_VALUE=128000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2026-03-27 kicadファイル作成
2026-03-28 docs:要件を書き出した
2026-03-28 docs:MCUをH523に変更
2026-03-28 docs:update README
2026-03-29 fix:ファームウェアはリポジトリ直下に置く
2026-04-01 PCB作成残りGNDのビア打ちをきちんとやるだけ
2026-04-02 CANFDのXHを縦にして発振器を変更
2026-04-02 MCUの向き決定 LSE HSE配置
2026-04-02 QuadSPI周りのピンの使用禁止
2026-04-02 cubemx保存し忘れてた
2026-04-03 DRC OK残りシルク
2026-04-03 PCBできたけどガーバーが出力できない
2026-04-04 PCB変更
2026-04-04 gn10can追加
2026-05-07 gn10-canを更新
2026-05-07 comit
2026-05-07 hubの書き直し
2026-05-07 あんまり進んでない
2026-05-09 一応エラーだけ消した
2026-05-10 内部クロックで再生
2026-05-11 can詰まり
2026-05-12 kous
2026-05-12 can動作確認
2026-05-13 esc-hub gn10_can完全実装
2026-05-13 20:55
2026-05-13 hubがまた動かなくなった
2026-05-14 cmake環境ファイルを保存
2026-05-14 generate code
2026-05-15 comi
2026-05-15 ☆復☆活☆D☆a☆z☆e☆！☆
2026-05-16 FDCAN
2026-05-17 fix:buildディレクトリは無視
2026-05-17 feat:remove maidui hal
2026-05-17 remove:project and submodule
2026-05-19 app内をきれいにした canは動くmaybe
2026-05-20 DCACHE有効化 ICACHEバス追加 動作確認済み
2026-05-20 レポートにより進捗低下
2026-05-21 キャリブレーション作成中
2026-05-25 PIの追加 基板PCB変更
2026-05-25 PID追加
2026-05-29 PID + FF 追加 多分うまくいく
2026-05-29 hal追加
2026-05-30 fix : FF起動時の比較にabs追加 FF条件をfloat形に修正
2026-06-09 hal変更
2026-06-09 fix : NULL対策 送信関数と初期化関数にNULL対策
2026-06-09 fix & docd : 起動確認用トグル追加 既存コードに対してコメントを追加
2026-06-09 fix : 昨日言っていた理由を今理解した。
2026-06-10 fix : 今度こそは動くはず
2026-06-11 fix : pid
2026-06-14 fix 積分少し変更？
2026-06-15 feat:送信テスト。問題なく送信できた。
2026-06-16 fix : cast
2026-06-16 refactor : update
2026-06-17 complete : PID
2026-06-19 chore:gn10-canを最新に更新
2026-06-19 chore:vscode settings
2026-06-19 feat:replace gains updater
2026-06-19 feat:STLink port to USB
2026-06-19 feat:remove
2026-06-19 feat:generate code
2026-06-19 feat:gn10-can周り実装
2026-06-19 feat:C620/C610通信用コード対か
2026-06-19 feat:動くようになった
2026-06-22 feat:set device id by dip switch
2026-06-22 feat:init受信後LEDが点灯するようにした
2026-06-22 chore:gn10-canを最新にしてmotor-typeを扱えるようにした
2026-06-22 feat:ギア比による出力軸の角速度換算は外部で行うためESC-Hubの機能から除外
2026-06-22 feat:電流変換や最大電流をC610/C620で自動設定
2026-06-22 fix:配列の初期化ミス
2026-06-23 featTX Fifoが空になるまで待つ
2026-06-23 fix:C6x0への指令値のDLCは4ではなく8
